<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\P1F1-TrafficLightController.ewp</path>
  </project>
  <batchBuild/>
</workspace>


